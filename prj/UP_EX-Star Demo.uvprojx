# Keil uVision project UP_EX-Star Demo.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UP_ADC +hex
  AfterMake: fromelf --bin -o !L@L.bin !L
  c flags: Optim=4 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\src\UpLib;..\src;..\src\UpLib\STM32Lib
  library: MicroLIB
  memory RVCT4: ROM 0x800b000 size 0x35000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Usr
    ../src/: main.c
    ../List/: UP_ADC.c
  group FwLib
    ../src/UpLib/STM32Lib/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c system_stm32f10x.c stm32f10x_exti.c
  group StartUp
    ../src/UpLib/STM32Lib/StartUp/: startup_stm32f10x_hd.s cortexm3_macro.s
  group UpLib
    ../src/UpLib/: UP_System.c UP_Globle.c UP_ADC.c UP_Key.c UP_LCD.c UP_UART.c UP_it.c UP_Exti.c UP_Timer.c UP_NVIC.c UP_PWM.c UP_Bluetooth.c UP_CDS5500.c UP_Zigbee.c UP_USR232.c UP_IOout.c UP_VGA.c UP_RFID.c UP_MP3.c UP_Variable.c UP_UART_Parse.c UP_Woody_VoicePlaying.c UP_Woody_SpeechRecognition.c UP_Woody_ImageRecognition.c
  group workspace
    ../src/: shangweiji.c shangweiji.h fsm.c fsm.h queue.c queue.h run.c run.h signal.h signal.c fighting.c fighting.h
software components: CMSIS:CORE 5.0.1
